options:
  parameters:
    generate_options: no_gui
    id: five_ant_correlation
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: int(2.56e6)
  states: {}
- name: to_phase
  id: variable
  parameters:
    value: 'lambda x: complex(math.cos(math.radians(x)),math.sin(math.radians(x)))'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: d0
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: d1
    type: complex
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: d2
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0
  id: blocks_delay
  parameters:
    delay: d3
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: d4
    type: complex
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: samp_rate
    type: complex
    vlen: '10'
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_1
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_2
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_3
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_4
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_5
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_6
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_7
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_8
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: to_phase(p1)
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: to_phase(p4)
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0_1
  id: blocks_multiply_const_xx
  parameters:
    const: to_phase(p2)
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0_2
  id: blocks_multiply_const_xx
  parameters:
    const: to_phase(p3)
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0_3
  id: blocks_multiply_const_xx
  parameters:
    const: to_phase(p0)
    type: complex
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: '10'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '10'
    type: complex
  states: {}
- name: d0
  id: parameter
  parameters:
    label: Chan 0 Delay
    type: intx
    value: '0'
  states: {}
- name: d1
  id: parameter
  parameters:
    label: Chan 1 Delay
    type: intx
    value: '0'
  states: {}
- name: d2
  id: parameter
  parameters:
    label: Chan 2 Delay
    type: intx
    value: '0'
  states: {}
- name: d3
  id: parameter
  parameters:
    label: Chan 3 Delay
    type: intx
    value: '0'
  states: {}
- name: d4
  id: parameter
  parameters:
    label: Chan 4 Delay
    type: intx
    value: '0'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: '"Center Frequency"'
    type: eng_float
    value: 1420.4058e6
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: kaddr
  id: parameter
  parameters:
    label: '"Address of KrakenSDR Server"'
    type: str
    value: '"127.0.0.1"'
  states: {}
- name: krakensdr_krakensdr_source_0
  id: krakensdr_krakensdr_source
  parameters:
    ctrlPort: '5001'
    debug: 'False'
    freq: freq
    gain: '[rfgain]*5'
    ipAddr: kaddr
    numChannels: '5'
    port: '5000'
  states: {}
- name: logtime
  id: parameter
  parameters:
    label: '"Logging Interval"'
    type: eng_float
    value: '10'
  states: {}
- name: longitude
  id: parameter
  parameters:
    label: Longitude
    type: eng_float
    value: '-76.03'
  states: {}
- name: me_logger
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time
      import ra_funcs


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """A slow data textual formatter
                inputs are expected to be science-data
                   Parameters:
                      formatter - pointer to a custom formatter function
                      filepat - pattern used for formatting filename must provide converters for YYYY MM DD
                      extension - filename extension
                      logtime - how often to log, in seconds
                      fmtstr - formatter for data values -- most provide converters for both values
                      nchan - number of interleaved channels on input"""
                      
                      

          def __init__(self, formatter=None, filepat="foonly-%d%d%d", extension=".csv", 
              logtime=10,fmtstr="%11.9f",nchan=1,localtime=False,longitude=-76.03, legend=None):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Correlator: Data Logger',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              
              #
              # Formatter is a function pointer--very often 'None'
              #
              self.formatter = formatter
              
              #
              # Controls the template for filename generation
              #
              self.filepat= filepat
              
              #
              # The filename extension
              #
              self.extension=extension
              
              #
              # The logging interval
              #
              self.logtime=logtime
              
              
              #
              # The data-item formatting string
              #      
              self.fmtstr = fmtstr
              
              #
              # How many (interleaved) channels
              self.nchan = nchan
              
              #
              # Use local time, rather than UTC/GMT?
              #
              self.localtime = localtime
              
              #
              # The averaing cells
              #
              self.avg = [0.0]*nchan
              self.acnt = [0]*nchan

              
              #
              # Keep track of the next channel's averaging cell we
              #  need to update
              #
              self.cndx = 0
              
              
              #
              # This isn't strictly required, since the work function code
              #  will take care of whatever items it gets presented with.
              #
              self.set_output_multiple(nchan)
              
              self.now = time.time()
              
              self.longitude = longitude
              
              self.legend = legend
              
              self.legcount = 0
              self.fn = ""
              self.curlegend = legend

          def work(self, input_items, output_items):
              
              if (self.localtime == False):
                  ltp = time.gmtime()
              else:
                  ltp = time.localtime()
              
              #
              # Distribute the input items over the averaging buffer as appropriate
              #  We assume that the input is interleaved by 'nchan'
              #  We use 'self.cndx' to keep track of which channel's averaging
              #  cell we need to put the next value in.
              #
              # Because GR's scheduler has no idea what our internal "shape"
              #  is, it can hand us many, or a few, items, every time we're
              #  called.
              #
              for x in range(len(input_items[0])):
                  self.avg[self.cndx % self.nchan] += input_items[0][x]
                  self.acnt[self.cndx % self.nchan] += 1
                  
                  #
                  # Increment and modularly reduce cndx
                  #
                  self.cndx += 1
                  self.cndx %= self.nchan
                  

              if ((time.time() - self.now) > self.logtime):
                  self.now = time.time()
                  if (self.formatter == None):
                      fn = self.filepat % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday) + self.extension
                      fp = open(fn, "a")
                      #
                      # Filename has changed (new date) or
                      #  legend has changed (new DEC/FREQ/BW) or
                      #  legcount >= 30
                      #
                      wrlegend = False
                      if (self.fn != fn):
                          self.fn = fn
                          wrlegend = True
                      elif (self.curlegend != self.legend):
                          self.curlegend = self.legend
                          wrlegend = True
                      elif (self.legcount >= 30):
                          wrlegend = True
                          self.legcount = 0
                      if (wrlegend == True and self.legend != None):
                          self.legcount = 0
                          fp.write("INFO:%s\n" % self.legend)
                          
                      fp.write("%02d,%02d,%02d," % (ltp.tm_hour, ltp.tm_min, ltp.tm_sec))
                      fp.write("%s," % ra_funcs.cur_sidereal(self.longitude))
                      for x in range(self.nchan):
                          self.avg[x] /= self.acnt[x]
                          self.acnt[x] = 1
                          fp.write (self.fmtstr  % (self.avg[x]))
                          if (x < self.nchan-1):
                              fp.write(",")
                      fp.write("\n")
                      self.legcount += 1
                      
                          
                      fp.close()
        
                  else:
                      self.formatter(self.filepat,self.extension,self.avg[0],self.avg[1])
                  
              return len(input_items[0])
    extension: '".csv"'
    filepat: prefix+'corr-%04d%02d%02d'
    fmtstr: '''%11.9f'''
    formatter: None
    legend: '"UTC,LMST,CH0_R,CH0_I,CH1_R,CH1_I,CH2_R,CH2_I,..."+"FREQ=%7.2f" % (freq/1.0e6)+",BW=%7.2f" % (samp_rate/1.0e6)'
    localtime: '0'
    logtime: logtime
    longitude: longitude
    nchan: '20'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: Delay blocks to compensate coarse cable imbalance
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: Complex multiplies to compensate fine phase delay
  states: {}
- name: p0
  id: parameter
  parameters:
    label: Chan 0 Phase
    type: eng_float
    value: '0'
  states: {}
- name: p1
  id: parameter
  parameters:
    label: Chan 1 Phase
    type: eng_float
    value: '0'
  states: {}
- name: p2
  id: parameter
  parameters:
    label: Chan 2 Phase
    type: eng_float
    value: '0'
  states: {}
- name: p3
  id: parameter
  parameters:
    label: Chan 3 Phase
    type: eng_float
    value: '0'
  states: {}
- name: p4
  id: parameter
  parameters:
    label: Chan 4 Phase
    type: eng_float
    value: '0'
  states: {}
- name: prefix
  id: parameter
  parameters:
    label: '"Fike Prefix"'
    type: str
    value: '"./"'
  states: {}
- name: rfgain
  id: parameter
  parameters:
    label: '"RF Gain"'
    type: eng_float
    value: '35'
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1.0/(samp_rate)
    type: complex
    vlen: '10'
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_interleave_0, '0']
- [blocks_complex_to_float_0, '1', blocks_interleave_0, '1']
- [blocks_delay_0, '0', blocks_multiply_const_xx_0_3, '0']
- [blocks_delay_0_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_delay_0_0_0, '0', blocks_multiply_const_xx_0_1, '0']
- [blocks_delay_0_0_0_0, '0', blocks_multiply_const_xx_0_2, '0']
- [blocks_delay_0_0_0_0_0, '0', blocks_multiply_const_xx_0_0, '0']
- [blocks_interleave_0, '0', me_logger, '0']
- [blocks_keep_one_in_n_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_streams_to_vector_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', blocks_streams_to_vector_0, '9']
- [blocks_multiply_conjugate_cc_0_1, '0', blocks_streams_to_vector_0, '2']
- [blocks_multiply_conjugate_cc_0_2, '0', blocks_streams_to_vector_0, '3']
- [blocks_multiply_conjugate_cc_0_3, '0', blocks_streams_to_vector_0, '4']
- [blocks_multiply_conjugate_cc_0_4, '0', blocks_streams_to_vector_0, '5']
- [blocks_multiply_conjugate_cc_0_5, '0', blocks_streams_to_vector_0, '6']
- [blocks_multiply_conjugate_cc_0_6, '0', blocks_streams_to_vector_0, '7']
- [blocks_multiply_conjugate_cc_0_7, '0', blocks_streams_to_vector_0, '8']
- [blocks_multiply_conjugate_cc_0_8, '0', blocks_streams_to_vector_0, '1']
- [blocks_multiply_const_xx_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_multiply_const_xx_0, '0', blocks_multiply_conjugate_cc_0_3, '0']
- [blocks_multiply_const_xx_0, '0', blocks_multiply_conjugate_cc_0_4, '0']
- [blocks_multiply_const_xx_0, '0', blocks_multiply_conjugate_cc_0_5, '0']
- [blocks_multiply_const_xx_0_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [blocks_multiply_const_xx_0_0, '0', blocks_multiply_conjugate_cc_0_2, '1']
- [blocks_multiply_const_xx_0_0, '0', blocks_multiply_conjugate_cc_0_5, '1']
- [blocks_multiply_const_xx_0_0, '0', blocks_multiply_conjugate_cc_0_7, '1']
- [blocks_multiply_const_xx_0_1, '0', blocks_multiply_conjugate_cc_0_3, '1']
- [blocks_multiply_const_xx_0_1, '0', blocks_multiply_conjugate_cc_0_6, '0']
- [blocks_multiply_const_xx_0_1, '0', blocks_multiply_conjugate_cc_0_7, '0']
- [blocks_multiply_const_xx_0_1, '0', blocks_multiply_conjugate_cc_0_8, '1']
- [blocks_multiply_const_xx_0_2, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [blocks_multiply_const_xx_0_2, '0', blocks_multiply_conjugate_cc_0_1, '1']
- [blocks_multiply_const_xx_0_2, '0', blocks_multiply_conjugate_cc_0_4, '1']
- [blocks_multiply_const_xx_0_2, '0', blocks_multiply_conjugate_cc_0_6, '1']
- [blocks_multiply_const_xx_0_3, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_multiply_const_xx_0_3, '0', blocks_multiply_conjugate_cc_0_1, '0']
- [blocks_multiply_const_xx_0_3, '0', blocks_multiply_conjugate_cc_0_2, '0']
- [blocks_multiply_const_xx_0_3, '0', blocks_multiply_conjugate_cc_0_8, '0']
- [blocks_streams_to_vector_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_float_0, '0']
- [krakensdr_krakensdr_source_0, '0', blocks_delay_0, '0']
- [krakensdr_krakensdr_source_0, '1', blocks_delay_0_0, '0']
- [krakensdr_krakensdr_source_0, '2', blocks_delay_0_0_0, '0']
- [krakensdr_krakensdr_source_0, '3', blocks_delay_0_0_0_0, '0']
- [krakensdr_krakensdr_source_0, '4', blocks_delay_0_0_0_0_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_keep_one_in_n_0, '0']

metadata:
  file_format: 1
